# Keil uVision project dasdsd.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Atmel Atmel Wireless & uC
  output: dasdsd +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\delay;.\funtion
  group Source Group 1
    ./: main.c
  group funtoin
    ./funtion/: beep.c LCD.c LED.c
  group delay
    ./delay/: delay.c
